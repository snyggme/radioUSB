# IAR project Backup of VirtualCom.ewp, settings and files
configuration Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC1347 NXP LPC1347
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: IAR_LPC1347_SK
  ICCARM.CCIncludePath2: ; app; board; modules
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: firmware.bin
  postbuild: ielftool --checksum __vector_table_0x1c:4,sum32:2;0-0x1B --bin "$EXE_DIR$\$PROJ_FNAME$.out" "$EXE_DIR$\$PROJ_FNAME$.bin"
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: cstartup_M.s main.c readme.txt
  group app
    app/: cd_class.c usb_dev_desc.c usb_hooks.c
  group modules
    modules/: drv_clk.c drv_nvic.c drv_OLED.c usb_buffer.c usb_hw.c usb_t9.c
